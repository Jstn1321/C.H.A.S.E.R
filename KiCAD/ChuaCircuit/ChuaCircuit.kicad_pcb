# Repository Jstn1321/C.H.A.S.E.R

File README.md:

<h1 align="center">C.H.A.S.E.R</h1>
<h4 align="center">CHAotic Secure Encryption for Real-time audio</h4>

---

<p align="center">
  <a href="#abstract">Abstract</a> •
  <a href="#methodology">Methodology</a> •
  <a href="#photoshoot">Photoshoot</a> •
  <a href="#demo">Demo</a> •
  <a href="#credits">Credits</a>
</p>

---

## Abstract

The digital standards for encryption today are RSA and AES; however, not every system can utilize their benefits. For instance, low-powered electronics and pure analog RF systems cannot support intensive algorithms like those listed above. This presents an alternative: hardware-based encryption, specifically using chaotic behavior and amplitude modulation techniques.

This project utilizes Chua's circuit, the simplest chaotic emitting circuit. Unlike digital encryption where keys exist digitally, this system's key is the hardware itself — using precise resistor and capacitor values. This principle exploits chaos theory's extreme parameter sensitivity, where circuits with only identical parameters synchronize and enable decryption, while circuits with just 1–2% component mismatches break decryption entirely.

Audio signals are encrypted by multiplication with two synchronized Chua circuit outputs and a 40 kHz carrier. The carrier translates encrypted signals above the audio band, enabling clean filtering during decryption. Matched chaotic frequencies reverse the encryption only when component values are identical.

Testing measured security by varying decryption circuit parameters from 0% to 10% mismatch. Signal-to-noise ratio degraded from 23.2 dB to 19.4 dB, while the noise floor increased by 120%. Audio becomes unintelligible at 2–5% mismatch, establishing that standard 5% tolerance components are insufficient — requiring attackers to have 1% precision matching and physical circuit access.

The system exhibits 43.46% harmonic distortion limiting audio clarity due to multiple multiplication steps; despite this, the work validates that hardware parameter sensitivity creates practical security for specialized applications where digital approaches cannot be used.

---

## Methodology

Chua's circuit was selected for this prototype as the simplest circuit capable of producing chaotic behavior. Its extreme sensitivity to initial conditions and parameter variations makes it well-suited for encryption. Amplitude modulation was chosen as the encryption methodology for its simplicity and low cost while still providing thorough encryption.

**Diagram of Chua's Circuit:**

**LTSpice Simulation:**

A 40 kHz carrier effectively separates the audio and key signals without significant overlap. Without the carrier, the Chua signal and audio would overlap considerably, reducing clarity. A Wien bridge oscillator is used alongside AD633 multiplier ICs to modulate the carrier, audio, and Chua circuit signals together.

---

## Photoshoot

**Double-scroll attractor:**

**Oscilloscope results:**

Photo of results (Blue: input signal, Yellow: encypted signal, Pink: Decrypted signal, Green: after filtering):

---

## Demo

Listen to me explain the project while utilizing chaotic encryption:

---

## Credits

[1] V. Siderskiy, "Chua Circuits," *Chua Circuits*. [Online]. Available: https://chuacircuits.com/. Accessed: Feb. 14, 2026.

[2] A. Shaik, "Amplitude Modulation – Physics and Radio-Electronics," *Physics and Radio-Electronics*. [Online]. Available: https://www.physics-and-radio-electronics.com/blog/amplitude-modulation/. Accessed: Feb. 15, 2026.

[3] L. Pecora and T. Carroll, "Synchronization in Chaotic Systems," *Physical Review Letters*, vol. 64, pp. 821–823, 1990. Accessed: Feb. 15, 2026.

[4] L. Kocarev, K. S. Halle, K. Eckert, L. O. Chua, and U. Parlitz, "Experimental demonstration of secure communications via chaotic synchronization," *Int. J. Bifurc. Chaos*, vol. 2, no. 3, pp. 709–713, 1992. Accessed: Feb. 15, 2026.

[5] E. Nazarenko, N. A. Anagnostopoulos, S. G. Stavrinides, N. Mexis, F. Frank, T. Arul, and S. Katzenbeisser, "Real-World Chaos-Based Cryptography Using Synchronized Chua Chaotic Circuits," *arXiv*, 2022. [Online]. Available: https://arxiv.org/abs/2210.11299. Accessed: Feb. 15, 2026.

[6] S. Baowidan, "Chaos-Driven Encryption Algorithm Integrated Logistic Chua Map for Secure Medical Image Communication," 2024. DOI: 10.21203/rs.3.rs-4692013/v1. Accessed: Feb. 15, 2026.

[7] "Electronic filters explained: from low pass to band stop," *Kistler*. [Online]. Available: https://www.kistler.com/NL/en/filter-electronics-/C00000109. Accessed: Feb. 16, 2026.

## KiCad design KiCAD/ChuaCircuit/ChuaCircuit.kicad_pcb

Parts:
+VCC1: Male_Header_1x1 2.54mm; PinHeader_1x01_P2.54mm_Vertical
-VCC1: Male_Header_1x1 2.54mm; PinHeader_1x01_P2.54mm_Vertical
C1: 10nF; C_0603_1608Metric; LCSC C22399611
C2, C3: 100nF; C_1206_3216Metric; LCSC C170182
C4: .01u; C_0603_1608Metric; LCSC C389113
C5, C6, C8, C10: 0.1u; C_0603_1608Metric; LCSC C24452
C7, C9, C11: 0.01u; C_0603_1608Metric; LCSC C389113
CHUA_OUT1: Male_Header_1x1 2.54mm; PinHeader_1x01_P2.54mm_Vertical
GND2: TP4; PinHeader_1x01_P2.54mm_Vertical
OPA1: TL084; SOIC127P600X175-14N; LCSC C11130
OPA2: TL082; SOIC127P600X175-8N; LCSC C13460
R1, R2: 220; R_0603_1608Metric; LCSC C22962
R3: 2.2K; R_0603_1608Metric; LCSC C4190
R4, R5: 22K; R_0603_1608Metric; LCSC C31850
R6: 3.3K; R_0603_1608Metric; LCSC C22978
R7: 100; R_0603_1608Metric; LCSC C22369795
R8, R9: 1K; R_0603_1608Metric; LCSC C21190
RV1: 5K; PinHeader_1x03_P2.54mm_Vertical
RV2: 5k; PinHeader_1x03_P2.54mm_Vertical
X1: TP3; PinHeader_1x01_P2.54mm_Vertical
Y1: TP2; PinHeader_1x01_P2.54mm_Vertical
Z1: TP1; PinHeader_1x01_P2.54mm_Vertical

Connections:
-VDC: -VCC1.1, C6.1, C7.1, C10.1, C11.1, OPA1.11 (V-), OPA2.4 (V-)
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, GND2.1, R3.1, R6.1, RV2.2, RV2.3
unnamed: C3.1, OPA1.8, R9.1
unnamed: CHUA_OUT1.1, OPA2.1, OPA2.2 (-)
unnamed: OPA1.1, R1.1, R2.1
unnamed: OPA1.7, R4.2, R5.2
unnamed: OPA1.14, R7.1, R8.2, Z1.1
unnamed: C1.1, OPA1.3 (+), OPA1.5 (+), OPA2.3 (+), R1.2, R4.1, RV1.2, RV1.3, X1.1
unnamed: OPA1.2 (-), R2.2, R3.2
unnamed: OPA1.6 (-), R5.1, R6.2
unnamed: C2.1, OPA1.10 (+), R7.2, RV1.1, Y1.1
unnamed: OPA1.9 (-), OPA1.13 (-), R8.1, R9.2
unnamed: C3.2, OPA1.12 (+), RV2.1
VCC: +VCC1.1, C4.1, C5.1, C8.1, C9.1, OPA1.4 (V+), OPA2.8 (V+)

Board: 2 copper layers, 29.5 x 31.0 mm, 31 parts (0 on the bottom side), 14 nets.

## Commit log

2025-11-09 Added Chua Circuit PCB/Schematics
2025-11-10 Finished schematic, need to add footprints for parts tho
2025-11-12 Fixed bug with wrong GND net name
2025-11-12 Moved back silkscreen text to front silkscreen
2025-11-13 Completed routing and the pcb design but need to make GND plane
2025-11-14 Added ground plane and changed the name of pcb
2025-11-23 Drastically changed schematic following good practice
2025-11-24 Moved the silkscreen on +VCC
2025-11-24 Added temporary BOM file
2025-12-18 Made a MATLAB simulation file
2025-12-18 Track raw files with Git LFS
2025-12-18 Moved into organized directory
2025-12-18 Ignore all .raw files
2025-12-19 Fix typo in Credits section header
2025-12-26 Finalized code for the arduino
2025-12-26 Added comments for threshold values
2025-12-26 Added the ltspice simulation for the envelope and gain op amp circuit
2025-12-26 Updated chua sim
2025-12-30 Addded a delay to reduce hysteresis
2025-12-30 Added analog switch ic datasheet
2025-12-30 Combined both simulations together
2026-01-01 Added some fft graphs for data
2026-01-01 Added time domain graphs
2026-01-01 Added pictures for parameter hopping
2026-01-29 Added ad633 datasheet
2026-01-29 Changed code so that we have two arduinos because one arduino wouldn't really make sense if we want reciever and transmitter
2026-01-29 Testing more encryption/decryption techniques in LtSpice
2026-01-29 Add Demo section and remove Data section from README
2026-02-04 Upated sim for new multiplication encryption and added a picture for the schematic
2026-02-05 Fixed the issue with -Vcc not being connected for some reason
2026-02-05 Updated schematic for sallen key hpf
2026-02-08 Remove obsolete LTSpice simulation file Chua.net
2026-02-25 Added LOTS of pictures
